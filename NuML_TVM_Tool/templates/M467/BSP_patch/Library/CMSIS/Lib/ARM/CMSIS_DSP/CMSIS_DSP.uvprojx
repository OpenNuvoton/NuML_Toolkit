# Keil uVision project CMSIS_DSP.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: cmsis_dsp (library)
  AfterMake: xcopy /Y .\Objects\cmsis_dsp.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ARM_MATH_DSP, ARM_MATH_LOOPUNROLL
  c include: ..\..\..\DSP\Include;..\..\..\DSP\PrivateInclude;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group BasicMathFunctions
    ../../../DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group BayesFunctions
    ../../../DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CommonTables
    ../../../DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group ComplexMathFunctions
    ../../../DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group ControllerFunctions
    ../../../DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group DistanceFunctions
    ../../../DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
  group FastMathFunctions
    ../../../DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group FilteringFunctions
    ../../../DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group InterpolationFunctions
    ../../../DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group MatrixFunctions
    ../../../DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group QuaternionMathFunctions
    ../../../DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group StatisticsFunctions
    ../../../DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group SupportFunctions
    ../../../DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group SVMFunctions
    ../../../DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group TransformFunctions
    ../../../DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
